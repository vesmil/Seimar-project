SRC_URI += "file://user_2021-08-05-10-05-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

